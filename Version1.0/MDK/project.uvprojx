# Keil uVision project project.uvprojx, settings and files
target Weixin (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Source\CMSIS;..\Source\Stm32Flib\inc;..\Source\User;..\Source\Bsp\dev;..\Source\Bsp\interface;..\Source\Bsp\test;..\Source\Bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Source/CMSIS/startup/: startup_stm32f10x_hd.s
  group cmsis
    ../Source/CMSIS/: core_cm3.c system_stm32f10x.c
  group stm32lib
    ../Source/Stm32Flib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../Source/User/: data.h main.c stm32f10x_it.c
    ../Source/Bsp/: bsp.c
  group interface
    ../Source/Bsp/interface/: delay.c iic.c sys.c usart.c adc.c
  group dev
    ../Source/Bsp/dev/: 24cxx.c tpswitch.c res.c io.c lcd12864.c
  group test
    ../Source/Bsp/test/: ostest.c upload.c show.c
software components: CMSIS:CORE 4.3.0
